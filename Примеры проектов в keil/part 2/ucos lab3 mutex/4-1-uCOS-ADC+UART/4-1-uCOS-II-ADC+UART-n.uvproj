# Keil uVision project 4-1-uCOS-II-ADC+UART-n.uvproj, settings and files
target OS-ADC-UART (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: OS-ADC-UART
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER  STM32F10X_MD
  c misc: --feedback=aaa.txt --c99
  c include: .\Src; ..\CMSIS; ..\BSP; ..\mC-CPU; ..\SPL\inc; ..\uCOS-Port; ..\uCOS-Src; ..\uC-LIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: ..\BSP\STM32_Flash0.scat
  link misc: --entry ResetHndlr  --feedback=aaa.txt
  group App
    ./Src/: uCOS_ADC_UART.c uCOS_ADC_UART_2Ch.c
    ./: uCOSHelloWorld.c uCOSSemaphore.c uCosPrioInv.c
  group CMSIS
    ../CMSIS/StartUp/: vectors.s
  group SPL
    ../SPL/src/: stm32f10x_rcc.c stm32f10x_gpio.c misc.c stm32f10x_adc.c stm32f10x_usart.c stm32f10x_flash.c
  group BSP
    ../BSP/: bsp.c init.s bsp_int.c bsp_periph.c
  group mC-CPU
    ../mC-CPU/: cpu_a.asm cpu_c.c
  group uCOS-Port
    ../uCOS-Port/: os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uCOS-Src
    ../uCOS-Src/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
target OS-ADC-UART-2Ch (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: OS-ADC-UART
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER  STM32F10X_MD
  c misc: --feedback=aaa.txt --c99
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: ..\BSP\STM32_Flash0.scat
  link misc: --entry ResetHndlr  --feedback=aaa.txt
target uCOSHelloWorld (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: OS-ADC-UART
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER  STM32F10X_MD
  c misc: --feedback=aaa.txt --c99
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: ..\BSP\STM32_Flash0.scat
  link misc: --entry ResetHndlr  --feedback=aaa.txt
target uCosSem (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: OS-ADC-UART
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER  STM32F10X_MD
  c misc: --feedback=aaa.txt --c99
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: ..\BSP\STM32_Flash0.scat
  link misc: --entry ResetHndlr  --feedback=aaa.txt
target uCosPrioInv (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: OS-ADC-UART
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER  STM32F10X_MD
  c misc: --feedback=aaa.txt --c99
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: ..\BSP\STM32_Flash0.scat
  link misc: --entry ResetHndlr  --feedback=aaa.txt
