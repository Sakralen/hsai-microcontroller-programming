# Keil uVision project ParP-Regs1.uvproj, settings and files
target ParP-Regs-N (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ParP-Regs_N
  c flags: Optim=1 oTime=1
  c define: USE_STDPERIPH_DRIVER STM32F10X_MD
  c misc: --feedback=aaa.txt  --c99
  c include: .\Src; ..\SPL\inc;..\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --feedback=aaa.txt
  group App
    ./Src/: ParP_Regs_N.c ParP_Regs_D.c ParP_Regs_DSnd.c
  group STM_Periph_Lib
    ../SPL/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
    ../CMSIS/StartUp/: startup_stm32f10x_md.s
target ParP-Regs-D (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: ParP-Regs_D
  c flags: Optim=1 oTime=1
  c define: USE_STDPERIPH_DRIVER STM32F10X_MD
  c misc: --feedback=aaa.txt  --c99
  c include: .\Src; ..\SPL\inc;..\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --feedback=aaa.txt
target ParP-Regs_DSnd (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: ParP-Regs_DSnd
  c flags: Optim=1 oTime=1
  c define: USE_STDPERIPH_DRIVER STM32F10X_MD_VL
  c misc: --feedback=aaa.txt  --c99
  c include: .\Src; ..\SPL\inc;..\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --feedback=aaa.txt
