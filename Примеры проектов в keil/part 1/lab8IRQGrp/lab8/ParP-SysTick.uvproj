# Keil uVision project ParP-SysTick.uvproj, settings and files
target SysTick (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: spl_exmp
  c flags: Optim=1 oTime=1
  c define: USE_STDPERIPH_DRIVER  STM32F10X_MD
  c misc: --feedback=aaa.txt  --c99
  c include: .\Src; ..\SPL\inc;..\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --feedback=aaa.txt
  group App
    ./Src/: SysTick.c
  group STM_Periph_Lib
    ../SPL/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
    ../CMSIS/StartUp/: startup_stm32f10x_md.s
  group Texts
    ./: Примечания_GPIO.txt
  group SPL
    ./STM32_SPL/src/: stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c
